Commit message: Robot funcionando del proyecto final

File: proyecto_ws/src/robot_description/urdf/robotinsano.urdf (robot description, URDF)
Before this commit: robot robot_rrr, 4 links, 3 joints
Joints:
- joint shoulder_joint: origin xyz=0 0 0 -> xyz=0 0 0.05
